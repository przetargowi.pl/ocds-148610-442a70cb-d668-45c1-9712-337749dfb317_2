Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: PR - 1012 - WADOWICE_v5.ifc
Time: 2025-11-20T15:18:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: Advance Steel
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 20 15:18:52 2025 * Host: ELA * Database: C:\Users\Ela\AppData\Local\Temp\{A6A12985-78B1-4F69-B8CA-2B9D5B1A1C08}\ifc * Database version: 5507 * Database creation date: Thu Nov 20 15:18:51 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 20 15:18:51 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 20 15:18:51 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcBeam: IPE220 (8)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: IPE220; SectionFamily: IPE wg PN

# IfcBeam: IPE240 (8)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: IPE240; SectionFamily: IPE wg PN

# IfcBeam: IPE360 (10)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: IPE360; SectionFamily: IPE wg PN

# IfcBeam: L60X6 (4)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: L60X6; SectionFamily: Angle_eq DIN18800-1

# IfcBeam: L60x60x3 (108)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: L60x60x3; SectionFamily: Usr Lukasz - L zimnogiete

# IfcBeam: Q100X3 (42)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: Q100X3; SectionFamily: RHS_Sections_square_c nach DIN

# IfcBeam: Q70X4 (10)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: Q70X4; SectionFamily: RHS_Sections_square_c nach DIN

# IfcBeam: Q80X3 (56)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: Q80X3; SectionFamily: RHS_Sections_square_c nach DIN

# IfcBeam: R180X100X4 (16)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: R180X100X4; SectionFamily: RHS_Sections_rectang_c nach DIN

# IfcBeam: RD16 (52)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: RD16; SectionFamily: Round nach DIN

# IfcBeam: RHS120x100x3 (11)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: RHS120x100x3; SectionFamily: Usr Lukasz - rury prostokatne

# IfcBeam: RHS120x100x4 (7)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: RHS120x100x4; SectionFamily: Usr Lukasz - rury prostokatne

# IfcBeam: Z 200x6860x2 (10)
In: Storey 1
Description: -; Material: S355, steel
ProfileProperties - Section: Z 200x6860x2; SectionFamily: Pruszynski Z

# IfcMechanicalFastener: Bolt (80)
NominalDiameter: 20 mm; NominalLength: 75 mm; Classification: 14399-4 (Unknown)

# IfcPlate (241)
In: Storey 1
Material: S355, steel
